#include <p32xxxx.h>
.global Print_Time_String
.text
.set noreorder
.ent Print_Time_String

.set WHATTIMEISIT, 0xA0000200

Print_Time_String:
    and s0, s0, zero 
    or s0, s0, ra
    nop                           # point PC here
    la t0, WHATTIMEISIT        # address of string -> t0
Load_Char_Print_Time_String:
                         #Send each char from the address pointed by t0
    lb t2, 0x0(t0)       # load char into t2
    beq t2, zero, Done_Print_Time_String   # t2 == 0 (NULL), done sending chars
    nop                  # otherwise continue (more chars to send)
    bal Print_Print_Time_String      # start subroutine ‘printChar’
    nop
                                    #return from printChar here
    addi t0, t0, 1                  # increment t0 pointer
    b Load_Char_Print_Time_String   # load next char
    nop
Print_Print_Time_String:
    lw t1,U1STA           # (status) U2STA (6210) -> t1
    andi t1,t1,0x200      # check transmit status
    bne t1,zero,Print_Print_Time_String  # cannot transmit now, try again
    nop                   # otherwise continue
    sb t2,U1TXREG         # char (t2) -> U2TXREG (6220)
    jr ra                 # return to ‘return from printChar here’
    nop
Done_Print_Time_String:
   nop
   jr s0
   nop

.end Print_Time_String
